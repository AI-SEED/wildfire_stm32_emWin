# Keil uVision project iSO-STM32.uvproj, settings and files
target emWin_Demo (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 流水灯 +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\STemWinLibrary522\inc;..\..\STemWinLibrary522\Config;..\..\User\lcd;..\..\User\SysTick;..\..\Demo;..\..\User\usart;..\..\User\sram;..\..\User\sdcard;..\..\ff9;..\..\User\WildfireGUI;..\..\PNGlib;..\..\User\rtc;..\..\User\t9py;..\..\User\ov7725;..\..\User\Key;..\..\User\dht11;..\..\User\TimBase;..\..\User\ds18b20;..\..\User\internal_temp;..\..\User\sim900a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_it.c main.c
  group bsp
    ../../User/usart/: bsp_usart1.c bsp_usart2.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/sdcard/: bsp_sdio_sdcard.c
    ../../User/led/: bsp_led.c
    ../../User/lcd/: bsp_gpio_spi.c bsp_ili9341_lcd.c bsp_touch.c
    ../../User/sram/: bsp_fsmc_sram.c
    ../../User/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
    ../../User/ov7725/: bsp_ov7725.c bsp_sccb.c
    ../../User/Key/: bsp_exti.c
    ../../User/dht11/: bsp_dht11.c
    ../../User/TimBase/: bsp_TIMbase.c
    ../../User/ds18b20/: bsp_ds18b20.c
    ../../User/internal_temp/: bsp_internal_temp.c
    ../../User/sim900a/: sim900a.c
  group WildfireGUI
    ../../User/WildfireGUI/: GUIDEMO_Touch.c WFGUI_DeskTop.c WFGUI_Icon.c WFGUI_SDView.c WFGUI_TextReader.c WFGUI_ImageReader.c WFGUI_Time.c WFGUI_Message.c WFGUI_Keypad.c WFGUI_Phone.c WFGUI_Camera.c WFGUI_Snapshot.c WFGUI_Temperature.c WFGUI_APPLinkedList.c
  group ff9
    ../../ff9/: diskio.c ff.c
    ../../ff9/option/: ccsbcs.c
  group STemWin_V522
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/OS/: GUI_X.c GUI_X_Touch_Analog.c
  group PNGlib
    ../../PNGlib/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group t9py
    ../../User/t9py/: t9py.c
  group DOC
    ../../Doc/: readme.txt
