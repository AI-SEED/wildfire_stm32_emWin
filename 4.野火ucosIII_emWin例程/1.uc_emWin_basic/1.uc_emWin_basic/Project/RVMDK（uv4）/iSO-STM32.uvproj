# Keil uVision project iSO-STM32.uvproj, settings and files
target uCOS_emWin_basic (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\App;..\..\uCOS-III\Source;..\..\uCOS-III\Ports;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\Cfg;..\..\uCOS-III\uC-LIB;..\..\STemWinLibrary522\inc;..\..\STemWinLibrary522\Config;..\..\Bsp\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/: main.c stm32f10x_it.c
  group App
    ../../App/: app.c
  group Bsp
    ../../Bsp/src/: bsp.c bsp_ili9341_lcd.c bsp_led.c
  group uC\Source
    ../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC\Ports
    ../../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC\Lib
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC\Cpu
    ../../uCOS-III/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group uC\Cfg
    ../../uCOS-III/Cfg/: os_app_hooks.c
  group STemWin_V522
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/OS/: GUI_X_uCOS.c
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_OS_Keil.lib
